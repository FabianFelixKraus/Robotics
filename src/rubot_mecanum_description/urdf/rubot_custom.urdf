Commit message: update files

File: src/rubot_mecanum_description/urdf/rubot_custom.urdf (robot description, URDF)
Before this commit: robot rubot, 10 links, 9 joints
Joints:
- joint scan_joint: origin xyz=0 0 0.15 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 3.1415926
